FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Use-BuilderBot-device-tree.patch"

UBOOT_SUFFIX = "img"
SPL_BINARY = "MLO"
